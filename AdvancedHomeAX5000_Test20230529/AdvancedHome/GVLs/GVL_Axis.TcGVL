//{attribute 'qualified_only'}
VAR_GLOBAL
	Axis_X						:AXIS_REF;
	iDigitalInput				AT%I*		:WORD;
	
END_VAR
